# Keil uVision project NewFrame_2.uvprojx, settings and files
target NewFrame_2 (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NewFrame_2 +hex
  c flags: oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3
  c define: __TARGET_FPU_VFP,STM32F407xx
  c misc: -Wno-empty-body
  c include: .;awlf\third_party\board\BSP\include;awlf\third_party\board\libraries\CMSIS\Include;awlf\third_party\board\libraries\STM32F4xx_HAL_Driver\Inc;awlf\third_party\FreeRTOS\include;awlf\third_party\FreeRTOS\portable;awlf\third_party\board\libraries\CMSIS\Include\CORE;awlf\third_party\board\libraries\CMSIS\Include\ST;awlf\lib
  asm define: __TARGET_FPU_VFP,STM32F407xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group AWLF/THIRD_PARTY/FREERTOS
    awlf/third_party/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group AWLF/THIRD_PARTY/FREERTOS/PORTABLE
    awlf/third_party/FreeRTOS/portable/: heap_4.c port.c
  group AWLF/THIRD_PARTY/BOARD/LIBRARIES/STM32F4XX_HAL_DRIVER/SRC
    awlf/third_party/board/libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group AWLF/THIRD_PARTY/BOARD/LIBRARIES/CMSIS/SOURCE/ST
    awlf/third_party/board/libraries/CMSIS/source/ST/: startup_stm32f407xx.s stm32f4xx_it.c system_stm32f4xx.c
  group AWLF/THIRD_PARTY/BOARD/BSP/SERIAL
    awlf/third_party/board/BSP/serial/: bsp_serial_impl.c bsp_serial_init.c serial_it.c
  group AWLF/THIRD_PARTY/BOARD/BSP/CORE
    awlf/third_party/board/BSP/core/: bsp_cpu.c bsp_dwt.c
  group AWLF/THIRD_PARTY/BOARD/BSP/CAN
    awlf/third_party/board/BSP/can/: bsp_can_impl.c bsp_can_it.c
  group AWLF/LIB/SOURCE/ITC
    awlf/lib/source/itc/: completion.c
  group AWLF/LIB/SOURCE/DRIVER/PAL_DEV/SERIAL
    awlf/lib/source/driver/pal_dev/serial/: hal_serial.c
  group AWLF/LIB/SOURCE/DRIVER/PAL_DEV/CAN
    awlf/lib/source/driver/pal_dev/can/: hal_can.c hal_canfd.c hal_can_core.c
  group AWLF/LIB/SOURCE/DRIVER/MODULES/MOTOR
    awlf/lib/source/driver/modules/motor/: motor_driver.c
  group AWLF/LIB/SOURCE/DRIVER/CORE
    awlf/lib/source/driver/core/: awlf_device.c
  group AWLF/LIB/SOURCE/DATA_STRUCT
    awlf/lib/source/data_struct/: avltree.c ringbuffer.c
  group AWLF/LIB/SOURCE/CORE
    awlf/lib/source/core/: awlf_cpu.c
  group AWLF/LIB/SOURCE/ALGORITHM/PROTOCOL
    awlf/lib/source/algorithm/protocol/: crc.c
  group AWLF/LIB/SOURCE/ALGORITHM/CONTROLLER
    awlf/lib/source/algorithm/controller/: pid.c
  group AWLF/LIB/COMPONENT/DRIVER/MODULES/MOTOR
    awlf/lib/component/driver/modules/motor/: dji.c dm.c
  group TEST/SERIAL_TEST_CRC
    test/serial_test_crc/: main.c protocol.c
  group TEST/GM6020_TEST
    test/GM6020_test/: main.c
  group TEST/CAN_TEST
    test/can_test/: main.c
  group <virtual_root>
    ./: .clangd .clang-format .gitignore Makefile
